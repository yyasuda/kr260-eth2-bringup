# Supply the flat GEM2/J10B PL design to the generic virtual/bitstream
# provider without depending on an absolute checkout path.
BITSTREAM_PATH := "${THISDIR}/../../../artifacts/gem2_j10b.bit"
